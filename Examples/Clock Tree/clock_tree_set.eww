<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\clock_tree_set.ewp</path>
    </project>
    <batchBuild />
</workspace>
