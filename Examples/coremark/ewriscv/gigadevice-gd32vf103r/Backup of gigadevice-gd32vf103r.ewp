# IAR project Backup of gigadevice-gd32vf103r.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: GD32VF103V-EVAL GigaDevice GD32VF103V-EVAL
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCIncludePath2: ../..; port
  OBJCOPY.OOCOutputFile: sifive-e21-arty-100t.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: sifive-e21-arty-100t.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group Coremark
    ../../: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h
  group Port
    port/: core_portme.c
