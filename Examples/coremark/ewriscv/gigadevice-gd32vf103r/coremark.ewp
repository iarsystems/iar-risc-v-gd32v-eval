# IAR project coremark.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: GD32VF103RBT6 GigaDevice GD32VF103RBT6
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCExtraOptions: --silent
  ICCRISCV.CCDefines: GD32VF103R_START
  ICCRISCV.CCIncludePath2: ../../../../GD32VF103_Firmware_Library/firmware/GD32VF103_standard_peripheral; ../../../../GD32VF103_Firmware_Library/firmware/GD32VF103_standard_peripheral/include; ../../../../GD32VF103_Firmware_Library/firmware/RISCV/drivers; ../../../../GD32VF103_Firmware_Library/firmware/RISCV/env_IAR; ../../../../bsp; $PROJ_DIR$; ../..; port
  OBJCOPY.OOCOutputFile: coremark.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: README.md
  group Coremark
    ../../: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h
  group Port
    port/: core_portme.c
    ../../../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral/: system_gd32vf103.c
