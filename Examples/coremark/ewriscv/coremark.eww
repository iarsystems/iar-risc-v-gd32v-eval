<?xml version="1.0" encoding="UTF-8"?>
<workspace>
	<project>
        <path>$WS_DIR$\gigadevice-gd32vf103r\gigadevice-gd32vf103r.ewp</path>
    </project>
    <batchBuild />
</workspace>
