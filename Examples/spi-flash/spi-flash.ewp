# IAR project spi-flash.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: GD32VF103RBT6 GigaDevice GD32VF103RBT6
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 0
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCExtraOptions: --silent; --nonportable_path_warnings
  ICCRISCV.CCDefines: GD32VF103R_START
  ICCRISCV.CCIncludePath2: ../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral; ../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral/Include; ../../GD32VF103_Firmware_Library/Firmware/RISCV/drivers; ../../GD32VF103_Firmware_Library/Firmware/RISCV/env_IAR; ../../bsp; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: Toggle_IO.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c README.md
  group BSP
    ../../bsp/: iar-risc-v-gd32v-eval.c LE25Uxx.c systick.c
  group FW
    ../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral/Source/: gd32vf103_eclic.c gd32vf103_gpio.c gd32vf103_rcu.c gd32vf103_spi.c gd32vf103_usart.c
    ../../GD32VF103_Firmware_Library/Firmware/RISCV/env_IAR/: low_level_init.c
    ../../GD32VF103_Firmware_Library/Firmware/RISCV/drivers/: n200_func.c
    ../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral/: system_gd32vf103.c
