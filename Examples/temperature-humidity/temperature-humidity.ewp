# IAR project temperature-humidity.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: GD32VF103RBT6 GigaDevice GD32VF103RBT6
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 0
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCExtraOptions: --silent; --nonportable_path_warnings
  ICCRISCV.CCDefines: GD32VF103R_START
  ICCRISCV.CCIncludePath2: ../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral; ../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral/Include; ../../GD32VF103_Firmware_Library/Firmware/RISCV/drivers; ../../GD32VF103_Firmware_Library/Firmware/RISCV/env_IAR; ../../bsp; ../../bsp/sht3x; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: temperature-humidity.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c README.md
  group BSP
    ../../bsp/: i2c.c iar-risc-v-gd32v-eval.c systick.c
  group BSP/SHT3x
    ../../bsp/sht3x/: sensirion_common.c sensirion_humidity_conversion.c sensirion_hw_i2c_implementation.c sensirion_temperature_unit_conversion.c sht3x.c
  group FW
    ../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral/Source/: gd32vf103_adc.c gd32vf103_eclic.c gd32vf103_gpio.c gd32vf103_i2c.c gd32vf103_rcu.c gd32vf103_usart.c
    ../../GD32VF103_Firmware_Library/Firmware/RISCV/env_IAR/: low_level_init.c
    ../../GD32VF103_Firmware_Library/Firmware/RISCV/drivers/: n200_func.c
    ../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral/: system_gd32vf103.c
