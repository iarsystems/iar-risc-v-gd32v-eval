# IAR project clock-tree.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: GD32VF103RBT6 GigaDevice GD32VF103RBT6
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 0
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: GD32VF103R_START
  ICCRISCV.CCIncludePath2: ../../firmware/GD32VF103_standard_peripheral; ../../firmware/GD32VF103_standard_peripheral/include; ../../firmware/RISCV/drivers; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: Toggle_IO.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: low_level_init.c main.c README.md
    ../../firmware/GD32VF103_standard_peripheral/: system_gd32vf103.c
  group DW
    ../../firmware/RISCV/drivers/: n200_func.c
