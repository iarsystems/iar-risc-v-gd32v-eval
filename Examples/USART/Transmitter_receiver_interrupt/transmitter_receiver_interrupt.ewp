# IAR project transmitter_receiver_interrupt.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: GD32VF103V-EVAL GigaDevice GD32VF103V-EVAL
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: GD32VF103V
  ICCRISCV.CCIncludePath2: ..\..\..\Utilities; ..\..\..\Utilities\LCD_common; ..\..\..\Firmware\GD32VF103_standard_peripheral; ..\..\..\Firmware\GD32VF103_standard_peripheral\Include; ..\..\..\Firmware\RISCV\drivers; $PROJ_DIR$
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: IarTestLed.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCDefines: GD32VF103V_EVAL
  group (top)
    ./: gd32vf103_it.c low_level_init.c main.c
    ../../../Utilities/: gd32vf103v_eval.c
    ../../../Firmware/GD32VF103_standard_peripheral/: system_gd32vf103.c
  group DRV
    ../../../Firmware/RISCV/drivers/: n200_func.c
  group FW
    ../../../Firmware/GD32VF103_standard_peripheral/Source/: gd32vf103_adc.c gd32vf103_bkp.c gd32vf103_can.c gd32vf103_crc.c gd32vf103_dac.c gd32vf103_dbg.c gd32vf103_dma.c gd32vf103_eclic.c gd32vf103_exmc.c gd32vf103_exti.c gd32vf103_fmc.c gd32vf103_fwdgt.c gd32vf103_gpio.c gd32vf103_i2c.c gd32vf103_pmu.c gd32vf103_rcu.c gd32vf103_rtc.c gd32vf103_spi.c gd32vf103_timer.c gd32vf103_usart.c gd32vf103_wwdgt.c
