# IAR project private-timer.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: GD32VF103RBT6 GigaDevice GD32VF103RBT6
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 0
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: GD32VF103R_START
  ICCRISCV.CCIncludePath2: ../../firmware/GD32VF103_standard_peripheral; ../../firmware/GD32VF103_standard_peripheral/include; ../../firmware/RISCV/drivers; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: Toggle_IO.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCDefines: NDEBUG
  group (top)
    ./: low_level_init.c main.c readme.txt systick.c README.md
    ../../Firmware/GD32VF103_standard_peripheral/: system_gd32vf103.c
  group DW
    ../../Firmware/RISCV/drivers/: n200_func.c
  group FW
    ../../Firmware/GD32VF103_standard_peripheral/Source/: gd32vf103_gpio.c gd32vf103_rcu.c
