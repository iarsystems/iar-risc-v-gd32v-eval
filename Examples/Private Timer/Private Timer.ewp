# IAR project Private Timer.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: GD32VF103V-EVAL GigaDevice GD32VF103V-EVAL
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: GD32VF103V
  ICCRISCV.CCIncludePath2: ..\..\Firmware\GD32VF103_standard_peripheral; ..\..\Firmware\GD32VF103_standard_peripheral\Include; ..\..\Firmware\RISCV\drivers; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: Private Timer.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: Private Timer.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCDefines: NDEBUG
  group (top)
    ./: main.c systick.c
    ../../Firmware/GD32VF103_standard_peripheral/: system_gd32vf103.c
  group DW
    ../../Firmware/RISCV/drivers/: n200_func.c
  group FW
    ../../Firmware/GD32VF103_standard_peripheral/Source/: gd32vf103_gpio.c gd32vf103_rcu.c
