<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Clock Tree\clock_tree_set.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Private Timer.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Toggle_IO\Toggle_IO.ewp</path>
    </project>
    <batchBuild />
</workspace>
