<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADC0_ADC1_regular_parallel.ewp</path>
    </project>
    <batchBuild />
</workspace>
