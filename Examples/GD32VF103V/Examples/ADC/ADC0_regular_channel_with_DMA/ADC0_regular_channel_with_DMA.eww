<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADC0_regular_channel_with_DMA.ewp</path>
    </project>
    <batchBuild />
</workspace>
