<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADC0_temperature_Vref.ewp</path>
    </project>
    <batchBuild />
</workspace>
