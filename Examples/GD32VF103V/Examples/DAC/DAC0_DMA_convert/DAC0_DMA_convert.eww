<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DAC0_DMA_convert.ewp</path>
    </project>
    <batchBuild />
</workspace>
