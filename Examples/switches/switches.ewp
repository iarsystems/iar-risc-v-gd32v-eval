# IAR project switches.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: GD32VF103RBT6 GigaDevice GD32VF103RBT6
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 0
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCExtraOptions: --silent
  ICCRISCV.CCDefines: GD32VF103R_START
  ICCRISCV.CCIncludePath2: ../../GD32VF103_Firmware_Library/firmware/GD32VF103_standard_peripheral; ../../GD32VF103_Firmware_Library/firmware/GD32VF103_standard_peripheral/include; ../../GD32VF103_Firmware_Library/firmware/RISCV/drivers; ../../GD32VF103_Firmware_Library/firmware/RISCV/env_IAR; ../../bsp; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: Toggle_IO.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c README.md
  group BSP
    ../../bsp/: iar-risc-v-gd32v-eval.c systick.c
  group FW
    ../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral/Source/: gd32vf103_eclic.c gd32vf103_exti.c gd32vf103_gpio.c gd32vf103_rcu.c
    ../../GD32VF103_Firmware_Library/Firmware/RISCV/env_IAR/: low_level_init.c
    ../../GD32VF103_Firmware_Library/Firmware/RISCV/drivers/: n200_func.c
    ../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral/: system_gd32vf103.c
