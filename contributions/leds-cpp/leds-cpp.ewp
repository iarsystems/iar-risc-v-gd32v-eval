# IAR project leds-cpp.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: GD32VF103RBT6 GigaDevice GD32VF103RBT6
  General.GHeapSize: 0x2000
  ICCRISCV.IccLang: 2
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCExtraOptions: --silent; --nonportable_path_warnings
  ICCRISCV.CCDefines: GD32VF103R_START
  ICCRISCV.CCIncludePath2: ../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral; ../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral/Include; ../../GD32VF103_Firmware_Library/Firmware/RISCV/drivers; ../../GD32VF103_Firmware_Library/Firmware/RISCV/env_IAR; ../../bsp/sht3x; ../../bsp; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: template-cpp.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: README.md
  group APP
    ./: led.cpp main.cpp systick.cpp
  group BSP
    ../../bsp/: i2c.c iar-risc-v-gd32v-eval.c LE25Uxx.c MMA8652.c
  group BSP/SHT3x
    ../../bsp/sht3x/: sensirion_common.c sensirion_humidity_conversion.c sensirion_hw_i2c_implementation.c sensirion_temperature_unit_conversion.c sht3x.c
  group FW
    ../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral/Source/: gd32vf103_adc.c gd32vf103_bkp.c gd32vf103_can.c gd32vf103_crc.c gd32vf103_dac.c gd32vf103_dbg.c gd32vf103_dma.c gd32vf103_eclic.c gd32vf103_exmc.c gd32vf103_exti.c gd32vf103_fmc.c gd32vf103_fwdgt.c gd32vf103_gpio.c gd32vf103_i2c.c gd32vf103_pmu.c gd32vf103_rcu.c gd32vf103_rtc.c gd32vf103_spi.c gd32vf103_timer.c gd32vf103_usart.c gd32vf103_wwdgt.c
    ../../GD32VF103_Firmware_Library/Firmware/RISCV/env_IAR/: low_level_init.c
    ../../GD32VF103_Firmware_Library/Firmware/RISCV/drivers/: n200_func.c
    ../../GD32VF103_Firmware_Library/Firmware/GD32VF103_standard_peripheral/: system_gd32vf103.c
